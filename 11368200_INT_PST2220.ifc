Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-08-22T09:39:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 22 09:39:56 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\43c4412d-f294-42fd-8851-fae253227b95\c40a4a77-3733-4d0b-9373-5d6417a26a84\ifc * Database version: 5507 * Database creation date: Tue Aug 22 09:39:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 22 09:39:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 22 09:39:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11368200_INT_PST2220:63222000_INT_11368200_PST2220, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 63222000_INT_11368200_PST2220
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 63222000_INT_11368200_PST2220
Material: z_Miele_Design_CLST, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
